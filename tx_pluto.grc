options:
  parameters:
    category: ''
    description: OpenWave hardware bring-up - TX half, drives a PlutoSDR. Repeats the message as a beacon so the RX side (rx_rtlsdr.grc, RTL-SDR) can be tuned/found without coordinating manual send timing across two separate radios.
    generate_options: qt_gui
    id: tx_pluto
    output_language: python
    title: OpenWave TX (PlutoSDR)
  states: {}

blocks:
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    comment: Rate the PHY (RRC pulse shaping etc.) actually runs at - same as phy_sim_loopback.grc's samp_rate. Too low to hand straight to Pluto's DAC.
    value: symbol_rate*sps
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: Pluto's actual DAC sample rate. Fixed at 960 kHz - a clean integer multiple of baseband_rate for every OpenWave mode (600/1200/2400/4800/9600 baud * sps=4), and comfortably within Pluto's valid sample-rate range.
    value: '960000'
  states: {}
- name: resamp_factor
  id: variable
  parameters:
    comment: Interpolation factor from baseband_rate up to radio_rate
    value: radio_rate // baseband_rate
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as the modulator's symbol table
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: beacon_period_ms
  id: variable
  parameters:
    comment: How often the beacon repeats the message, for RX-side tuning/hunting
    value: '4000'
  states: {}
- name: center_freq_default
  id: parameter
  parameters:
    comment: 70cm amateur band - only the STARTING frequency; retune live via the Center Freq slider once running.
    short_id: f
    type: intx
    value: '433000000'
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    comment: Live frequency tuning, in MHz (matches Pluto's own 47 MHz-6 GHz valid range). center_freq (Hz) below is derived from this and is what every block actually uses.
    gui_hint: 1,0,1,1
    label: Center Freq (MHz)
    start: '47.0'
    step: '0.001'
    stop: '6000.0'
    value: center_freq_default/1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Derived from the live center_freq_mhz control - everything downstream (Pluto sink) references this, in Hz, unchanged.
    value: int(center_freq_mhz*1e6)
  states: {}
- name: pluto_uri
  id: parameter
  parameters:
    comment: Leave blank to auto-discover over USB (iio.get_pluto_uri()); set explicitly for a network-attached Pluto, e.g. 'ip:192.168.2.1'
    short_id: u
    type: str
    value: ''''''
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    comment: TX attenuation in dB (0 = max power). Start high (e.g. 50-60) for a bench test at close range, lower for range testing.
    short_id: a
    type: eng_float
    value: '50.0'
  states: {}
- name: msg
  id: parameter
  parameters:
    short_id: m
    type: str
    value: '"OpenWave pi/4-QPSK PHY test 123!"'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600. Must match rx_rtlsdr.grc's symbol_rate.
    short_id: r
    type: intx
    value: '600'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Beacon repeat - resends the (fixed, at flowgraph-start) message content on a timer, so the RX side has a known, repeating signal to find and tune against instead of needing a coordinated one-shot manual send.
    msg: pmt.string_to_symbol(msg)
    period: beacon_period_ms
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Regroup individual bits into 2-bit symbols (0..3)
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack 8-bit bytes into individual bits
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tx_const.points()
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Mod-8 phase accumulator - makes it pi/4-QPSK instead of plain QPSK. See phy_sim_loopback.grc for the full explanation.
    modulus: '8'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Symbol value (0..3) -> odd ring position (1,3,5,7)
    map: '[1, 3, 5, 7]'
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: RRC pulse shaping, alpha=0.35 - runs at baseband_rate
    interp: sps
    taps: firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11*sps)
    type: ccf
  states: {}
- name: filter_rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Upsamples from baseband_rate (where the PHY runs) to radio_rate (Pluto's actual DAC rate) - a plain anti-imaging interpolator, not pulse shaping (that already happened above).
    decim: '1'
    interp: resamp_factor
    type: ccf
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '20000000'
    buffer_size: '0x8000'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    len_tag_key: '""'
    samplerate: radio_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Manual override - sends immediately on edit, independent of the beacon timer
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Send now
    type: string
    value: msg
  states: {}
- name: str_to_pdu_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Wraps an incoming string message (from a QT GUI Message Edit Box or the
      beacon strobe) into full OpenWave link-layer frame(s) - preamble, sync word,
      header (with real Payload Length, Sequence Number, and Flags fields), payload,
      and CRC32 - using the shared openwave_link module so TX and RX can't drift out
      of sync on the framing format. Ready for PDU to Tagged Stream.

      Messages longer than openwave_link.MAX_PAYLOAD_LEN are automatically split
      into multiple fragment frames (openwave_link.build_fragmented_frames) - each
      fragment is published as a separate PDU/burst, transparently to whoever
      called handle_msg. Sequence Number increments once per fragment (not once per
      logical message): a fragmented message consumes several consecutive seq
      numbers, one per fragment, since that's how RX's FragmentReassembler
      correlates them (see openwave_link.py's module docstring for the protocol-
      design gap this works around - there's no dedicated fragment-index field).

      ack_requested sets the Flags byte's ACK Requested bit and engages
      openwave_link.RetryManager, but ONLY for messages that fit in a single frame.
      RetryManager tracks one pending frame at a time, so partially tracking just a
      fragmented message's last fragment wouldn't actually guarantee the whole
      message arrived - fragmented sends are deliberately not ACK/retry-tracked in
      this phase, regardless of ack_requested.

      If 'tick' (wired to a periodic message strobe in the .grc) fires and the
      pending (unfragmented) frame has timed out, it's retransmitted, up to
      ack_max_retries times before giving up (published on 'delivery_failed'). Feed
      a received ACK's seq into 'ack_received' to resolve a pending retry - nothing
      in this flowgraph currently wires that from a real over-the-air ACK (see
      stream_display_sink_0's docstring for why), so on tx_pluto.grc/
      phy_sim_loopback.grc as they stand today, ack_requested frames will always
      eventually hit 'delivery_failed' - the retry logic itself is real and tested,
      just not yet connected to a real return path.
      """
      from gnuradio import gr
      import pmt
      import sys, os
      if os.getcwd() not in sys.path:
          sys.path.insert(0, os.getcwd())
      import openwave_link as link


      class blk(gr.basic_block):
          """String to OpenWave Frame PDU"""

          def __init__(self, lead_pad=24, end_pad=24, ack_requested=False,
                       ack_max_retries=3, ack_timeout_s=2.0):
              gr.basic_block.__init__(self, name='String to OpenWave Frame PDU', in_sig=[], out_sig=[])
              self.lead_pad = lead_pad
              self.end_pad = end_pad
              self.ack_requested = ack_requested
              self.flags = link.FLAG_ACK_REQUESTED if ack_requested else 0
              self.seq = 0
              self.retry_mgr = link.RetryManager(max_retries=ack_max_retries, timeout_s=ack_timeout_s)
              self._pending_payload = None
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_in(pmt.intern('ack_received'))
              self.message_port_register_in(pmt.intern('tick'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.message_port_register_out(pmt.intern('delivery_failed'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)
              self.set_msg_handler(pmt.intern('ack_received'), self.handle_ack_received)
              self.set_msg_handler(pmt.intern('tick'), self.handle_tick)

          def _publish_frame(self, frame):
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(frame), list(frame)))
              self.message_port_pub(pmt.intern('pdus'), pdu)

          def _send_single_frame(self, payload, seq):
              """Used only for retransmitting an already-unfragmented pending frame -
              fragmented messages are never retry-tracked, see class docstring."""
              frame = link.build_frame(payload, lead_pad=self.lead_pad, end_pad=self.end_pad,
                                        seq=seq, flags=self.flags)
              self._publish_frame(frame)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              text = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(msg)
              payload = text.encode('utf-8')

              frames, next_seq = link.build_fragmented_frames(
                  payload, seq_start=self.seq, flags=self.flags,
                  lead_pad=self.lead_pad, end_pad=self.end_pad,
              )
              fragmented = len(frames) > 1
              first_seq = self.seq
              self.seq = next_seq

              for frame in frames:
                  self._publish_frame(frame)

              if self.ack_requested and not fragmented:
                  self._pending_payload = payload
                  self.retry_mgr.note_sent(first_seq)

          def handle_ack_received(self, msg):
              acked_seq = pmt.to_long(msg)
              self.retry_mgr.note_ack(acked_seq)

          def handle_tick(self, msg):
              status = self.retry_mgr.poll()
              if status == 'retry':
                  seq = self.retry_mgr.pending_seq
                  self._send_single_frame(self._pending_payload, seq)
                  self.retry_mgr.note_sent(seq)
              elif status == 'give_up':
                  self.message_port_pub(pmt.intern('delivery_failed'), pmt.from_long(self.seq))
                  self._pending_payload = None
    end_pad: '24'
    lead_pad: '24'
    ack_requested: 'False'
    ack_max_retries: '3'
    ack_timeout_s: '2.0'
  states: {}
- name: blocks_message_strobe_ack_tick
  id: blocks_message_strobe
  parameters:
    comment: Drives str_to_pdu_0's ACK-retry timeout polling - unrelated to (and much faster than) any beacon strobe in this flowgraph.
    msg: pmt.PMT_T
    period: '500'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, str_to_pdu_0, msg]
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', filter_rational_resampler_xxx_0, '0']
- [filter_rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [qtgui_edit_box_msg_0, msg, str_to_pdu_0, msg]
- [str_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_message_strobe_ack_tick, strobe, str_to_pdu_0, tick]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
