options:
  parameters:
    category: ''
    description: OpenWave hardware bring-up - RX half, RTL-SDR.
    generate_options: qt_gui
    id: rx_rtlsdr
    output_language: python
    title: OpenWave RX (RTL-SDR)
  states: {}

blocks:
- name: baseband_rate
  id: variable
  parameters:
    comment: Rate the PHY (Symbol Sync etc.) actually runs at - same as phy_sim_loopback.grc's samp_rate. Too low for the RTL-SDR's ADC to run at directly.
    value: symbol_rate*sps
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Derived from the live center_freq_mhz control - everything downstream (RTL-SDR source, xlating filter, spectrum plot) references this, in Hz, unchanged.
    value: int(center_freq_mhz*1e6)
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    comment: Live frequency tuning, in MHz (24 MHz-1766 MHz covers the RTL-SDR/R820T2's practical tuning range). center_freq (Hz) below is derived from this and is what every block actually uses.
    gui_hint: 0,0,1,1
    label: Center Freq (MHz)
    start: '24.0'
    step: '0.001'
    stop: '1766.0'
    value: center_freq_default/1e6
    widget: eng_slider
  states: {}
- name: decode_const
  id: variable_constellation
  parameters:
    comment: Just the 4 odd (45/135/225/315 degree) ring positions, mapped back to their original 2-bit symbol values - slices the diff_phasor_cc output straight back to data with no separate differential-decode step
    const_points: '[ring_points[1], ring_points[3], ring_points[5], ring_points[7]]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: freq_offset
  id: variable
  parameters:
    comment: RTL LO is tuned this far below center_freq, and the xlating filter shifts back by the same amount while decimating - keeps the RTL-SDR's DC-offset spike off of our actual signal instead of sitting right on top of it.
    value: '100000'
  states: {}
- name: nfilters
  id: variable
  parameters:
    comment: Number of arms in Symbol Sync's polyphase matched-filter bank
    value: '128'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: RTL-SDR's actual ADC sample rate. Fixed at 1.92 MHz - a clean integer multiple of baseband_rate for every OpenWave mode, within the RTL-SDR's valid higher sample-rate range (900,001-3,200,000 Hz), and wide enough that the spectrum plot's axis auto-displays in MHz instead of kHz (confirmed empirically - below roughly 1-2 MHz of span it switches to kHz).
    value: '1920000'
  states: {}
- name: resamp_factor
  id: variable
  parameters:
    comment: Decimation factor from radio_rate down to baseband_rate
    value: radio_rate // baseband_rate
  states: {}
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as Symbol Sync's decision-directed slicer
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: center_freq_default
  id: parameter
  parameters:
    comment: 70cm amateur band - must match tx_pluto.grc's center_freq. Only the STARTING frequency; retune live via the Center Freq slider once running.
    short_id: f
    type: intx
    value: '433000000'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices straight back to the 2-bit symbol value
    constellation: decode_const
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''1001100000011000100111111100101100011010110011111111110000011101'''
    comment: Tags the bit immediately following a match against the last 4 bytes of the PN preamble (openwave_link.PREAMBLE) + the OpenWave sync word (openwave_link.SYNC_WORD). GNU Radio's correlator caps access codes at 64 bits, so the full preamble+syncword can't be used directly as the correlation target, though the full 32-byte preamble is still transmitted. This value is a hardcoded literal, not a live reference to openwave_link.py - GRC's Import block doesn't actually share its namespace with other blocks' parameter expressions in this GNU Radio version (confirmed empirically), so it can't be. Kept in sync by tests/test_flowgraphs_compile.py's access-code consistency check - if PREAMBLE or SYNC_WORD ever change, that test will fail until this literal is regenerated.
    tagname: '"sync"'
    threshold: '4'
    type: byte
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential phase detection - immune to constant carrier phase offset, so no Costas loop needed. NOT immune to a moving frequency offset - if the Pluto/RTL-SDR clock mismatch drifts faster than expected, this is the first place to look.
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: RRC matched filter, alpha=0.35, done as a polyphase matched filter inside Symbol Sync itself - see phy_sim_loopback.grc for why a separate pre-filter block caused a symbol-count slip during acquisition.
    constellation: tx_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: nfilters
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilters, sps*nfilters, 1.0, 0.35, 11*sps*nfilters)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    comment: Shifts the signal (offset-tuned to dodge the RTL-SDR's DC spike) back to baseband while decimating from radio_rate down to baseband_rate. This is channel selection, not RRC matched filtering - that's still done by Symbol Sync's own PFB matched filter further down the chain, same as phy_sim_loopback.grc. Cutoff/transition are a reasonable starting point - may need tightening once real hardware is in the loop.
    decim: resamp_factor
    samp_rate: radio_rate
    taps: firdes.low_pass(1.0, radio_rate, baseband_rate*0.45, baseband_rate*0.35)
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '''rtl=0'''
    bb_gain0: '20'
    comment: Tunes the RTL LO to center_freq - freq_offset; the xlating filter downstream shifts back and decimates to baseband_rate.
    corr0: rtl_ppm
    freq0: center_freq - freq_offset
    gain0: rtl_gain
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: radio_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Plots the diff_phasor_cc output. Four tight clusters at 45/135/225/315 degrees means the modem is decoding cleanly.
    gui_hint: 3,0,1,1
    size: '256'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: radio_rate
    comment: Raw spectrum straight off the RTL-SDR, before the xlating filter - useful for finding the beacon and confirming freq_offset/ppm are sane.
    fc: center_freq - freq_offset
    fftsize: '1024'
    gui_hint: 2,0,1,1
    type: complex
  states: {}
- name: rtl_gain
  id: parameter
  parameters:
    comment: Manual RF gain in dB
    short_id: g
    type: eng_float
    value: '40.0'
  states: {}
- name: rtl_ppm
  id: parameter
  parameters:
    comment: Manual frequency correction in ppm. Calibrate with `rtl_test -p` (or equivalent) before the first test - RTL-SDR crystal error is often tens of ppm, which at UHF can be several kHz, potentially larger than the whole channel.
    short_id: c
    type: eng_float
    value: '0.0'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Uses the 'sync' tag from the access-code correlator to know exactly where the
      header starts, then uses openwave_link.FrameParser to collect exactly
      Header+Payload+CRC32 bytes (per the header's real Payload Length field) and
      verify the CRC before publishing. No zero-run-terminator guessing - the header
      tells us exactly how many bytes to expect, and the CRC tells us whether we got
      them right.

      Tracks Sequence Number (gap/duplicate detection) and parses Flags from each
      CRC-verified frame - never from a CRC-failed one, since a corrupted header can
      still unpack without a struct error while holding garbage values. Counts and
      the last frame's seq/flags/mode/src/dst are published on the 'stats' port.

      station_id (blank by default) is this receiver's own callsign. Blank means
      "not configured to filter" - every CRC-verified frame is accepted, which is
      also the only sane default today since no TX chain populates a real
      Destination ID yet (openwave_link.py's docstring) - they all send the same
      all-zero placeholder. Once set, only frames addressed to station_id or a
      broadcast (the literal 'ALL' callsign, or that same all-zero placeholder) are
      processed further; everything else is counted under 'not_for_us' and dropped
      before ACK/fragment/message handling - see openwave_link.is_for_station().

      capture_file (blank by default = disabled) appends every completed frame
      attempt - 'ok', 'crc_fail', AND 'bad_length' alike, not just successful ones,
      since a rejected frame is usually the more interesting one when debugging a
      real problem later - to a file in exactly openwave_link.build_frame()'s byte
      format (PREAMBLE + SYNC_WORD + whatever header/payload/CRC bytes were
      actually collected for that attempt). That means openwave_cli.py's `dump`/
      `recv` commands can process a capture file with zero changes - see
      openwave_link.iter_frames()/describe_frames(). Opened in append mode so
      restarting this flowgraph doesn't clobber a previous session's capture.

      Distinguishes three kinds of CRC-verified, for-us frame:
        - ACK frames (openwave_link.is_ack): publish the acknowledged seq on
          'ack_received' instead of trying to decode the (empty) payload as text.
        - Fragmented Data frames: fed through openwave_link.FragmentReassembler;
          'msg' is only published once the full run completes, transparently to
          whoever's listening on 'msg' (a reassembled message looks identical to a
          single-frame one).
        - Plain Data frames: decoded and published on 'msg' directly, as before.
      A Data frame (fragmented or not) with the ack_requested flag publishes its
      seq on 'ack_needed'.

      Nothing in this flowgraph currently transmits a real ACK back in response to
      'ack_needed', or feeds a real received ACK into 'ack_received' - RTL-SDR has
      no transmit capability at all, so this station can never send an ACK back
      over the air. These ports exist so the logic is ready for a future
      full-duplex pairing.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys, os
      if os.getcwd() not in sys.path:
          sys.path.insert(0, os.getcwd())
      import openwave_link as link


      class blk(gr.sync_block):
          """Sync-word-aligned, header-framed bit stream to message"""

          def __init__(self, tagname='sync', station_id='', capture_file=''):
              gr.sync_block.__init__(self, name='Framed Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.tagname = tagname
              self.station_id = station_id
              self.capture_file = capture_file
              self._capture_fh = open(capture_file, 'ab') if capture_file else None
              self.parser = link.FrameParser()
              self.reassembler = link.FragmentReassembler()
              self.armed = False
              self.bitpos = 0
              self.curbyte = 0
              self.counts = {'ok': 0, 'crc_fail': 0, 'bad_length': 0, 'dup': 0, 'lost': 0,
                              'acks_rx': 0, 'frag_aborted': 0, 'frag_overflow': 0, 'not_for_us': 0}
              self.last_seq = None
              self.last_flags = 0
              self.last_mode = 0
              self.last_src = ''
              self.last_dst = ''
              self.message_port_register_out(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('stats'))
              self.message_port_register_out(pmt.intern('ack_needed'))
              self.message_port_register_out(pmt.intern('ack_received'))

          def stop(self):
              if self._capture_fh is not None:
                  self._capture_fh.close()
                  self._capture_fh = None
              return True

          def _capture_attempt(self):
              if self._capture_fh is not None:
                  self._capture_fh.write(link.PREAMBLE + link.SYNC_WORD + bytes(self.parser.buf))
                  self._capture_fh.flush()

          def _publish_stats(self):
              c = self.counts
              seq_str = str(self.last_seq) if self.last_seq is not None else '-'
              text = (f"OK:{c['ok']}  CRC fail:{c['crc_fail']}  Bad length:{c['bad_length']}  "
                      f"Dup:{c['dup']}  Lost:{c['lost']}  ACKs rx:{c['acks_rx']}  "
                      f"Frag abort:{c['frag_aborted']}  Frag overflow:{c['frag_overflow']}  "
                      f"Not for us:{c['not_for_us']}  |  "
                      f"Seq:{seq_str}  Flags:{link.format_flags(self.last_flags)}  "
                      f"{link.format_mode(self.last_mode)}  "
                      f"Src:{self.last_src or '-'}  Dst:{self.last_dst or '-'}")
              self.message_port_pub(pmt.intern('stats'), pmt.string_to_symbol(text))

          def _update_seq(self, header):
              seq = header['seq']
              if self.last_seq is not None:
                  if seq == self.last_seq:
                      self.counts['dup'] += 1
                  else:
                      gap = (seq - self.last_seq - 1) % link.SEQ_MODULUS
                      # Bound the gap we'll believe as real loss vs. e.g. TX having
                      # restarted (seq reset to 0) - avoids one bogus huge count.
                      if 0 < gap < 1000:
                          self.counts['lost'] += gap
              self.last_seq = seq
              self.last_flags = header['flags']

          def _update_addressing(self, header):
              self.last_mode = header['mode_id']
              self.last_src = link.decode_station_id(header['src_id'])
              self.last_dst = link.decode_station_id(header['dst_id'])

          def _publish_text_and_maybe_ack(self, header, payload_bytes):
              self.counts['ok'] += 1
              text = payload_bytes.decode('utf-8', errors='replace')
              if text:
                  self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))
              if link.needs_ack(header):
                  self.message_port_pub(pmt.intern('ack_needed'), pmt.from_long(header['seq']))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern(self.tagname))
              tag_offsets = {t.offset - self.nitems_read(0) for t in tags}

              for i, bit in enumerate(in0):
                  if i in tag_offsets:
                      self.parser.reset()
                      self.armed = True
                      self.bitpos = 0
                      self.curbyte = 0

                  if not self.armed:
                      continue

                  self.curbyte = (self.curbyte << 1) | int(bit)
                  self.bitpos += 1
                  if self.bitpos == 8:
                      status, payload = self.parser.feed(self.curbyte)
                      self.bitpos = 0
                      self.curbyte = 0
                      if status == 'ok':
                          header = self.parser.last_header
                          self._update_seq(header)
                          self._update_addressing(header)
                          self._capture_attempt()

                          if not link.is_for_station(header['dst_id'], self.station_id):
                              self.counts['not_for_us'] += 1
                          elif link.is_ack(header):
                              self.counts['acks_rx'] += 1
                              self.message_port_pub(pmt.intern('ack_received'), pmt.from_long(header['seq']))
                          elif link.parse_flags(header['flags'])['fragmented']:
                              frag_status, reassembled = self.reassembler.feed(header, payload)
                              self.counts['frag_aborted'] = self.reassembler.abort_count
                              self.counts['frag_overflow'] = self.reassembler.overflow_count
                              if frag_status == 'complete':
                                  self._publish_text_and_maybe_ack(header, reassembled)
                          else:
                              self._publish_text_and_maybe_ack(header, payload)

                          self._publish_stats()
                          self.armed = False
                      elif status in ('crc_fail', 'bad_length'):
                          self.counts[status] += 1
                          self._capture_attempt()
                          self._publish_stats()
                          self.armed = False

              return len(in0)
    tagname: '''sync'''
    station_id: station_id
    capture_file: capture_file
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600. Must match tx_pluto.grc's symbol_rate.
    short_id: r
    type: intx
    value: '600'
  states: {}
- name: station_id
  id: parameter
  parameters:
    comment: This receiver's own callsign for Destination ID address filtering (see openwave_link.is_for_station()). Blank (default) = accept every frame, unfiltered - matches today's TX chains, which don't populate a real Destination ID yet.
    short_id: s
    type: str
    value: ''''''
  states: {}
- name: capture_file
  id: parameter
  parameters:
    comment: Path to append every completed frame attempt (ok, crc_fail, and bad_length alike) to, in openwave_link.build_frame()'s byte format - directly readable with openwave_cli.py's dump/recv commands. Blank (default) = capture disabled.
    short_id: o
    type: str
    value: ''''''
  states: {}
- name: qtgui_edit_box_msg_stats
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 4,0,1,1
    is_pair: 'False'
    label: Link Stats
    type: string
    value: '""'
  states: {}

connections:
- [blocks_unpack_k_bits_bb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', stream_display_sink_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [filter_freq_xlating_fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [osmosdr_source_0, '0', filter_freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]
- [stream_display_sink_0, stats, qtgui_edit_box_msg_stats, val]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
