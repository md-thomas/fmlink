options:
  parameters:
    category: ''
    generate_options: qt_gui
    id: test1
    output_language: python
    title: QPSK Differential Modem
  states: {}

blocks:
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Regroup individual bits into 2-bit symbols (0..3)
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Repack individual bits into 8-bit bytes
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack 8-bit bytes into individual bits
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.001'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qpsk_const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.05'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11*sps)
    type: ccf
  states: {}
- name: msg
  id: parameter
  parameters:
    short_id: m
    type: str
    value: '"GNU Radio QPSK Differential Transmission Test 123!"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Send
    type: string
    value: msg
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: str_to_pdu_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Wraps an incoming string message (from a QT GUI Message Edit Box) into a
      zero-padded byte-vector PDU, ready for PDU to Tagged Stream.

      The padding absorbs sync-loop acquisition transients and filter group delay so
      the real payload isn't the first/last thing in each burst.
      """
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          """String to Padded PDU"""

          def __init__(self, pad=48):
              gr.basic_block.__init__(self, name='String to Padded PDU', in_sig=[], out_sig=[])
              self.pad = pad
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              text = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(msg)
              payload = b'\x00' * self.pad + text.encode('utf-8') + b'\x00' * self.pad
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(payload), list(payload)))
              self.message_port_pub(pmt.intern('pdus'), pdu)
    pad: '48'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Scans a rolling buffer of the received byte stream for the zero-padding
      markers placed around each message on the TX side, and publishes the
      framed text as a message whenever it changes. Avoids relying on stream
      tags, which don't survive the adaptive symbol-sync/Costas loop chain
      precisely enough for an isolated one-shot burst.
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Rolling-buffer byte stream to message"""

          def __init__(self, pad=8, bufsize=512):
              gr.sync_block.__init__(self, name='Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.pad = pad
              self.bufsize = bufsize
              self.buf = bytearray()
              self.last = None
              self.message_port_register_out(pmt.intern('msg'))

          def work(self, input_items, output_items):
              data = input_items[0].tobytes()
              self.buf.extend(data)
              if len(self.buf) > self.bufsize:
                  del self.buf[:len(self.buf) - self.bufsize]

              zero_run = b'\x00' * self.pad
              buf = bytes(self.buf)

              # Find every complete zero-delimited segment currently in the
              # window and keep the last (most recent) one - older messages
              # can still be sitting in the buffer alongside a newer one.
              segments = []
              pos = 0
              while True:
                  start = buf.find(zero_run, pos)
                  if start == -1:
                      break
                  payload_start = start
                  while payload_start < len(buf) and buf[payload_start] == 0:
                      payload_start += 1
                  end = buf.find(zero_run, payload_start)
                  if end == -1 or end <= payload_start:
                      break
                  segments.append(buf[payload_start:end])
                  pos = end

              if segments:
                  text = segments[-1].decode('utf-8', errors='replace')
                  if text and text != self.last:
                      self.last = text
                      self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))

              return len(data)
    bufsize: '512'
    pad: '8'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    short_id: r
    type: intx
    value: '4800'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_pack_k_bits_bb_1, '0', stream_display_sink_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_1, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [qtgui_edit_box_msg_0, msg, str_to_pdu_0, msg]
- [str_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
