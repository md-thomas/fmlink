options:
  parameters:
    category: ''
    description: OpenWave hardware bring-up - RX half, RTL-SDR.
    generate_options: qt_gui
    id: test3_rx
    output_language: python
    title: OpenWave RX (RTL-SDR)
  states: {}

blocks:
- name: baseband_rate
  id: variable
  parameters:
    comment: Rate the PHY (Symbol Sync etc.) actually runs at - same as test2.grc's samp_rate. Too low for the RTL-SDR's ADC to run at directly.
    value: symbol_rate*sps
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Derived from the live center_freq_mhz control - everything downstream (RTL-SDR source, xlating filter, spectrum plot) references this, in Hz, unchanged.
    value: int(center_freq_mhz*1e6)
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    comment: Live frequency tuning, in MHz (24 MHz-1766 MHz covers the RTL-SDR/R820T2's practical tuning range). center_freq (Hz) below is derived from this and is what every block actually uses.
    gui_hint: 0,0,1,1
    label: Center Freq (MHz)
    start: '24.0'
    step: '0.001'
    stop: '1766.0'
    value: center_freq_default/1e6
    widget: eng_slider
  states: {}
- name: decode_const
  id: variable_constellation
  parameters:
    comment: Just the 4 odd (45/135/225/315 degree) ring positions, mapped back to their original 2-bit symbol values - slices the diff_phasor_cc output straight back to data with no separate differential-decode step
    const_points: '[ring_points[1], ring_points[3], ring_points[5], ring_points[7]]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: freq_offset
  id: variable
  parameters:
    comment: RTL LO is tuned this far below center_freq, and the xlating filter shifts back by the same amount while decimating - keeps the RTL-SDR's DC-offset spike off of our actual signal instead of sitting right on top of it.
    value: '100000'
  states: {}
- name: nfilters
  id: variable
  parameters:
    comment: Number of arms in Symbol Sync's polyphase matched-filter bank
    value: '128'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: RTL-SDR's actual ADC sample rate. Fixed at 1.92 MHz - a clean integer multiple of baseband_rate for every OpenWave mode, within the RTL-SDR's valid higher sample-rate range (900,001-3,200,000 Hz), and wide enough that the spectrum plot's axis auto-displays in MHz instead of kHz (confirmed empirically - below roughly 1-2 MHz of span it switches to kHz).
    value: '1920000'
  states: {}
- name: resamp_factor
  id: variable
  parameters:
    comment: Decimation factor from radio_rate down to baseband_rate
    value: radio_rate // baseband_rate
  states: {}
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as Symbol Sync's decision-directed slicer
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: center_freq_default
  id: parameter
  parameters:
    comment: 70cm amateur band - must match test3_tx.grc's center_freq. Only the STARTING frequency; retune live via the Center Freq slider once running.
    short_id: f
    type: intx
    value: '433000000'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices straight back to the 2-bit symbol value
    constellation: decode_const
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''''.join(format(b, ''08b'') for b in (b''\x55''*4 + b''\x1A\xCF\xFC\x1D''))'
    comment: Tags the bit immediately following a match against the last 4 bytes of the preamble + the OpenWave sync word 0x1ACFFC1D. See test2.grc for why only 64 of the 96 preamble+syncword bits are used as the correlation target.
    tagname: '"sync"'
    threshold: '4'
    type: byte
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential phase detection - immune to constant carrier phase offset, so no Costas loop needed. NOT immune to a moving frequency offset - if the Pluto/RTL-SDR clock mismatch drifts faster than expected, this is the first place to look.
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: RRC matched filter, alpha=0.35, done as a polyphase matched filter inside Symbol Sync itself - see test2.grc for why a separate pre-filter block caused a symbol-count slip during acquisition.
    constellation: tx_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: nfilters
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilters, sps*nfilters, 1.0, 0.35, 11*sps*nfilters)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    comment: Shifts the signal (offset-tuned to dodge the RTL-SDR's DC spike) back to baseband while decimating from radio_rate down to baseband_rate. This is channel selection, not RRC matched filtering - that's still done by Symbol Sync's own PFB matched filter further down the chain, same as test2.grc. Cutoff/transition are a reasonable starting point - may need tightening once real hardware is in the loop.
    decim: resamp_factor
    samp_rate: radio_rate
    taps: firdes.low_pass(1.0, radio_rate, baseband_rate*0.45, baseband_rate*0.35)
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '''rtl=0'''
    bb_gain0: '20'
    comment: Tunes the RTL LO to center_freq - freq_offset; the xlating filter downstream shifts back and decimates to baseband_rate.
    corr0: rtl_ppm
    freq0: center_freq - freq_offset
    gain0: rtl_gain
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: radio_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Plots the diff_phasor_cc output. Four tight clusters at 45/135/225/315 degrees means the modem is decoding cleanly.
    gui_hint: 3,0,1,1
    size: '256'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: radio_rate
    comment: Raw spectrum straight off the RTL-SDR, before the xlating filter - useful for finding the beacon and confirming freq_offset/ppm are sane.
    fc: center_freq - freq_offset
    fftsize: '1024'
    gui_hint: 2,0,1,1
    type: complex
  states: {}
- name: rtl_gain
  id: parameter
  parameters:
    comment: Manual RF gain in dB
    short_id: g
    type: eng_float
    value: '40.0'
  states: {}
- name: rtl_ppm
  id: parameter
  parameters:
    comment: Manual frequency correction in ppm. Calibrate with `rtl_test -p` (or equivalent) before the first test - RTL-SDR crystal error is often tens of ppm, which at UHF can be several kHz, potentially larger than the whole channel.
    short_id: c
    type: eng_float
    value: '0.0'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Uses the 'sync' tag emitted by the access-code correlator to know exactly
      which bit is the start of the payload - no more guessing a bit-to-byte
      phase. Packs bits into bytes from that point and publishes the payload
      once a run of zero bytes (temporary end-of-message marker, until a real
      Payload Length header field exists) is seen.

      term_len is deliberately smaller than how much zero padding TX actually
      sends (see str_to_pdu_0's end_pad), since the filter/timing-recovery
      pipeline's group delay means the last several trailing bytes never
      arrive once the finite burst source goes idle - there's nothing left to
      flush them through.
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Sync-word-aligned bit stream to message"""

          def __init__(self, term_len=8, max_payload_bytes=256, tagname='sync'):
              gr.sync_block.__init__(self, name='Framed Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.term_len = term_len
              self.max_payload_bytes = max_payload_bytes
              self.tagname = tagname
              self.bits = []
              self.armed = False
              self.message_port_register_out(pmt.intern('msg'))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern(self.tagname))
              tag_offsets = {t.offset - self.nitems_read(0) for t in tags}

              for i, bit in enumerate(in0):
                  if i in tag_offsets:
                      self.bits = []
                      self.armed = True
                  if self.armed:
                      self.bits.append(int(bit))
                      if len(self.bits) >= self.max_payload_bytes * 8:
                          self.armed = False
                          self.bits = []
                          continue
                      if len(self.bits) % 8 == 0 and len(self.bits) >= self.term_len * 8:
                          byts = np.packbits(np.array(self.bits, dtype=np.uint8)).tobytes()
                          zero_run = b'\x00' * self.term_len
                          idx = byts.find(zero_run)
                          if idx != -1:
                              text = byts[:idx].decode('utf-8', errors='replace')
                              if text:
                                  self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))
                              self.armed = False
                              self.bits = []

              return len(in0)
    max_payload_bytes: '256'
    tagname: '''sync'''
    term_len: '8'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600. Must match test3_tx.grc's symbol_rate.
    short_id: r
    type: intx
    value: '600'
  states: {}

connections:
- [blocks_unpack_k_bits_bb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', stream_display_sink_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [filter_freq_xlating_fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [osmosdr_source_0, '0', filter_freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
