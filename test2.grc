options:
  parameters:
    category: ''
    description: OpenWave phase 1 - pi/4-QPSK PHY + preamble/sync-word framing. No header/CRC32/FEC/interleaving yet.
    generate_options: qt_gui
    id: test2
    output_language: python
    title: OpenWave pi/4-QPSK PHY Test
  states: {}

blocks:
- name: decode_const
  id: variable_constellation
  parameters:
    comment: Just the 4 odd (45/135/225/315 degree) ring positions, mapped back to their original 2-bit symbol values - slices the diff_phasor_cc output straight back to data with no separate differential-decode step
    const_points: '[ring_points[1], ring_points[3], ring_points[5], ring_points[7]]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: nfilters
  id: variable
  parameters:
    comment: Number of arms in Symbol Sync's polyphase matched-filter bank
    value: '128'
  states: {}
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as the modulator's symbol table and as Symbol Sync's decision-directed slicer
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Regroup individual bits into 2-bit symbols (0..3)
    k: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack 8-bit bytes into individual bits
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: frequency_offset=0.0 - differential detection below is immune to constant phase offset but NOT to a moving frequency offset, so this hasn't been exercised
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.001'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tx_const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices straight back to the 2-bit symbol value - no separate differential-decode step needed
    constellation: decode_const
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''''.join(format(b, ''08b'') for b in (b''\x55''*4 + b''\x1A\xCF\xFC\x1D''))'
    comment: Tags the bit immediately following a match against the last 4 bytes of the preamble + the OpenWave sync word 0x1ACFFC1D (GNU Radio's correlator caps access codes at 64 bits, so the full 96-bit preamble+syncword can't be used directly as the correlation target, though the full 8-byte preamble is still transmitted). This is what tells the RX side exactly which bit is the start of the payload, instead of guessing a bit-to-byte phase.
    tagname: '"sync"'
    threshold: '4'
    type: byte
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Mod-8 phase accumulator. Accumulating an odd value mod 8 always flips the result's parity, so the transmitted point alternates between the "even" and "odd" halves of the ring every symbol - this is what actually makes it pi/4-QPSK instead of plain QPSK.
    modulus: '8'
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential phase detection - recovers the original odd-ring increment directly from the phase difference between consecutive symbols. Immune to constant carrier phase offset, so no Costas loop is needed here the way plain QPSK needs one.
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Symbol value (0..3) -> odd ring position (1,3,5,7). The even positions are never used directly as input.
    map: '[1, 3, 5, 7]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: RRC matched filter, alpha=0.35, done as a polyphase matched filter inside Symbol Sync itself rather than as a separate FIR block ahead of it. A separate pre-filter changes the pulse shape feeding the M&M timing error detector in a way that isn't accounted for by the loop's tuning, and was observed to cause a deterministic symbol-count offset (a "slip") during acquisition. Doing the matched filtering and timing recovery together in one block keeps the TED's operating point consistent.
    constellation: tx_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: nfilters
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilters, sps*nfilters, 1.0, 0.35, 11*sps*nfilters)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: RRC pulse shaping, alpha=0.35
    interp: sps
    taps: firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11*sps)
    type: ccf
  states: {}
- name: msg
  id: parameter
  parameters:
    short_id: m
    type: str
    value: '"OpenWave pi/4-QPSK PHY test 123!"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Plots the diff_phasor_cc output - the recovered phase increments, immune to carrier phase offset. Four tight clusters at 45/135/225/315 degrees means the modem is decoding cleanly.
    gui_hint: 2,0,1,1
    size: '256'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Send
    type: string
    value: msg
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: str_to_pdu_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Wraps an incoming string message (from a QT GUI Message Edit Box) into a
      PDU framed with a timing preamble, the OpenWave sync word,
      and a temporary zero-run end marker (until a real Payload Length header
      field exists), ready for PDU to Tagged Stream. The lead-in zeros give
      Symbol Sync's acquisition loop time to settle before the preamble
      arrives; the trailing zeros give the matched-filter/timing-recovery
      pipeline's group delay somewhere to flush into once the real payload
      ends.
      """
      from gnuradio import gr
      import pmt

      PREAMBLE = b'\x55' * 8
      SYNC_WORD = b'\x1A\xCF\xFC\x1D'


      class blk(gr.basic_block):
          """String to Framed PDU"""

          def __init__(self, lead_pad=24, end_pad=24):
              gr.basic_block.__init__(self, name='String to Framed PDU', in_sig=[], out_sig=[])
              self.lead_pad = lead_pad
              self.end_pad = end_pad
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              text = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(msg)
              payload = (b'\x00' * self.lead_pad + PREAMBLE + SYNC_WORD +
                         text.encode('utf-8') + b'\x00' * self.end_pad)
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(payload), list(payload)))
              self.message_port_pub(pmt.intern('pdus'), pdu)
    end_pad: '24'
    lead_pad: '24'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Uses the 'sync' tag emitted by the access-code correlator to know exactly
      which bit is the start of the payload - no more guessing a bit-to-byte
      phase. Packs bits into bytes from that point and publishes the payload
      once a run of zero bytes (temporary end-of-message marker, until a real
      Payload Length header field exists) is seen.

      term_len is deliberately smaller than how much zero padding TX actually
      sends (see str_to_pdu_0's end_pad), since the filter/timing-recovery
      pipeline's group delay means the last several trailing bytes never
      arrive once the finite burst source goes idle - there's nothing left to
      flush them through.
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Sync-word-aligned bit stream to message"""

          def __init__(self, term_len=8, max_payload_bytes=256, tagname='sync'):
              gr.sync_block.__init__(self, name='Framed Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.term_len = term_len
              self.max_payload_bytes = max_payload_bytes
              self.tagname = tagname
              self.bits = []
              self.armed = False
              self.message_port_register_out(pmt.intern('msg'))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern(self.tagname))
              tag_offsets = {t.offset - self.nitems_read(0) for t in tags}

              for i, bit in enumerate(in0):
                  if i in tag_offsets:
                      self.bits = []
                      self.armed = True
                  if self.armed:
                      self.bits.append(int(bit))
                      if len(self.bits) >= self.max_payload_bytes * 8:
                          self.armed = False
                          self.bits = []
                          continue
                      if len(self.bits) % 8 == 0 and len(self.bits) >= self.term_len * 8:
                          byts = np.packbits(np.array(self.bits, dtype=np.uint8)).tobytes()
                          zero_run = b'\x00' * self.term_len
                          idx = byts.find(zero_run)
                          if idx != -1:
                              text = byts[:idx].decode('utf-8', errors='replace')
                              if text:
                                  self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))
                              self.armed = False
                              self.bits = []

              return len(in0)
    max_payload_bytes: '256'
    tagname: '''sync'''
    term_len: '8'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600
    short_id: r
    type: intx
    value: '4800'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', stream_display_sink_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [qtgui_edit_box_msg_0, msg, str_to_pdu_0, msg]
- [str_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
