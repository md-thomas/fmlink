options:
  parameters:
    category: ''
    description: OpenWave phase 1 - pi/4-QPSK physical layer only, no framing yet
    generate_options: qt_gui
    id: test2
    output_language: python
    title: OpenWave pi/4-QPSK PHY Test
  states: {}

blocks:
- name: decode_const
  id: variable_constellation
  parameters:
    comment: Just the 4 odd (45/135/225/315 degree) ring positions, mapped back to their original 2-bit symbol values - slices the diff_phasor_cc output straight back to data with no separate differential-decode step
    const_points: '[ring_points[1], ring_points[3], ring_points[5], ring_points[7]]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as the modulator's symbol table and as Symbol Sync's decision-directed slicer
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Regroup individual bits into 2-bit symbols (0..3)
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Repack individual bits into 8-bit bytes
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack 8-bit bytes into individual bits
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: frequency_offset=0.0 - differential detection below is immune to constant phase offset but NOT to a moving frequency offset, so this hasn't been exercised
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.001'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tx_const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices straight back to the 2-bit symbol value - no separate differential-decode step needed
    constellation: decode_const
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Mod-8 phase accumulator. Accumulating an odd value mod 8 always flips the result's parity, so the transmitted point alternates between the "even" and "odd" halves of the ring every symbol - this is what actually makes it pi/4-QPSK instead of plain QPSK.
    modulus: '8'
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential phase detection - recovers the original odd-ring increment directly from the phase difference between consecutive symbols. Immune to constant carrier phase offset, so no Costas loop is needed here the way plain QPSK needs one.
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Symbol value (0..3) -> odd ring position (1,3,5,7). The even positions are never used directly as input.
    map: '[1, 3, 5, 7]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: tx_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: RRC pulse shaping, alpha=0.35
    interp: sps
    taps: firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11*sps)
    type: ccf
  states: {}
- name: msg
  id: parameter
  parameters:
    short_id: m
    type: str
    value: '"OpenWave pi/4-QPSK PHY test 123!"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Plots the diff_phasor_cc output - the recovered phase increments, immune to carrier phase offset. Four tight clusters at 45/135/225/315 degrees means the modem is decoding cleanly.
    gui_hint: 2,0,1,1
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Send
    type: string
    value: msg
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: str_to_pdu_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Wraps an incoming string message (from a QT GUI Message Edit Box) into a
      zero-padded byte-vector PDU, ready for PDU to Tagged Stream.

      The padding absorbs sync-loop acquisition transients and filter group
      delay so the real payload isn't the first/last thing in each burst.
      """
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          """String to Padded PDU"""

          def __init__(self, pad=48):
              gr.basic_block.__init__(self, name='String to Padded PDU', in_sig=[], out_sig=[])
              self.pad = pad
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              text = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(msg)
              payload = b'\x00' * self.pad + text.encode('utf-8') + b'\x00' * self.pad
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(payload), list(payload)))
              self.message_port_pub(pmt.intern('pdus'), pdu)
    pad: '48'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Scans a rolling buffer of the received byte stream for the zero-padding
      markers placed around each message on the TX side, and publishes the
      framed text as a message whenever it changes. Avoids relying on stream
      tags, which don't survive the adaptive symbol-sync chain precisely
      enough for an isolated one-shot burst.
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Rolling-buffer byte stream to message"""

          def __init__(self, pad=8, bufsize=512):
              gr.sync_block.__init__(self, name='Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.pad = pad
              self.bufsize = bufsize
              self.buf = bytearray()
              self.last = None
              self.message_port_register_out(pmt.intern('msg'))

          def work(self, input_items, output_items):
              data = input_items[0].tobytes()
              self.buf.extend(data)
              if len(self.buf) > self.bufsize:
                  del self.buf[:len(self.buf) - self.bufsize]

              zero_run = b'\x00' * self.pad
              buf = bytes(self.buf)

              # Find every complete zero-delimited segment currently in the
              # window and keep the last (most recent) one - older messages
              # can still be sitting in the buffer alongside a newer one.
              segments = []
              pos = 0
              while True:
                  start = buf.find(zero_run, pos)
                  if start == -1:
                      break
                  payload_start = start
                  while payload_start < len(buf) and buf[payload_start] == 0:
                      payload_start += 1
                  end = buf.find(zero_run, payload_start)
                  if end == -1 or end <= payload_start:
                      break
                  segments.append(buf[payload_start:end])
                  pos = end

              if segments:
                  text = segments[-1].decode('utf-8', errors='replace')
                  if text and text != self.last:
                      self.last = text
                      self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))

              return len(data)
    bufsize: '512'
    pad: '8'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600
    short_id: r
    type: intx
    value: '4800'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_pack_k_bits_bb_1, '0', stream_display_sink_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_1, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [qtgui_edit_box_msg_0, msg, str_to_pdu_0, msg]
- [str_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
