options:
  parameters:
    category: ''
    description: OpenWave phase 1 - pi/4-QPSK PHY + preamble/sync-word framing. No header/CRC32/FEC/interleaving yet.
    generate_options: qt_gui
    id: phy_sim_loopback
    output_language: python
    title: OpenWave PHY Simulated Loopback
  states: {}

blocks:
- name: decode_const
  id: variable_constellation
  parameters:
    comment: Just the 4 odd (45/135/225/315 degree) ring positions, mapped back to their original 2-bit symbol values - slices the diff_phasor_cc output straight back to data with no separate differential-decode step
    const_points: '[ring_points[1], ring_points[3], ring_points[5], ring_points[7]]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: nfilters
  id: variable
  parameters:
    comment: Number of arms in Symbol Sync's polyphase matched-filter bank
    value: '128'
  states: {}
- name: ring_points
  id: variable
  parameters:
    comment: 8 unit points at 0,45,90,...,315 degrees, sequential index order - the union of both 45-degree-apart QPSK constellations that pi/4-QPSK alternates between
    value: '[1+0j, (2**0.5/2)+(2**0.5/2)*1j, 1j, -(2**0.5/2)+(2**0.5/2)*1j, -1+0j, -(2**0.5/2)-(2**0.5/2)*1j, -1j, (2**0.5/2)-(2**0.5/2)*1j]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_const
  id: variable_constellation
  parameters:
    comment: All 8 ring points - used as the modulator's symbol table and as Symbol Sync's decision-directed slicer
    const_points: ring_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Regroup individual bits into 2-bit symbols (0..3)
    k: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack 8-bit bytes into individual bits
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Split 2-bit symbols back into individual bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: frequency_offset=0.0 - differential detection below is immune to constant phase offset but NOT to a moving frequency offset, so this hasn't been exercised
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tx_const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices straight back to the 2-bit symbol value - no separate differential-decode step needed
    constellation: decode_const
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''1001100000011000100111111100101100011010110011111111110000011101'''
    comment: Tags the bit immediately following a match against the last 4 bytes of the PN preamble (openwave_link.PREAMBLE) + the OpenWave sync word (openwave_link.SYNC_WORD). GNU Radio's correlator caps access codes at 64 bits, so the full preamble+syncword can't be used directly as the correlation target, though the full 32-byte preamble is still transmitted. This value is a hardcoded literal, not a live reference to openwave_link.py - GRC's Import block doesn't actually share its namespace with other blocks' parameter expressions in this GNU Radio version (confirmed empirically), so it can't be. Kept in sync by tests/test_flowgraphs_compile.py's access-code consistency check - if PREAMBLE or SYNC_WORD ever change, that test will fail until this literal is regenerated.
    tagname: '"sync"'
    threshold: '4'
    type: byte
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Mod-8 phase accumulator. Accumulating an odd value mod 8 always flips the result's parity, so the transmitted point alternates between the "even" and "odd" halves of the ring every symbol - this is what actually makes it pi/4-QPSK instead of plain QPSK.
    modulus: '8'
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential phase detection - recovers the original odd-ring increment directly from the phase difference between consecutive symbols. Immune to constant carrier phase offset, so no Costas loop is needed here the way plain QPSK needs one.
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Symbol value (0..3) -> odd ring position (1,3,5,7). The even positions are never used directly as input.
    map: '[1, 3, 5, 7]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: RRC matched filter, alpha=0.35, done as a polyphase matched filter inside Symbol Sync itself rather than as a separate FIR block ahead of it. A separate pre-filter changes the pulse shape feeding the M&M timing error detector in a way that isn't accounted for by the loop's tuning, and was observed to cause a deterministic symbol-count offset (a "slip") during acquisition. Doing the matched filtering and timing recovery together in one block keeps the TED's operating point consistent.
    constellation: tx_const
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: nfilters
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilters, sps*nfilters, 1.0, 0.35, 11*sps*nfilters)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: RRC pulse shaping, alpha=0.35
    interp: sps
    taps: firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11*sps)
    type: ccf
  states: {}
- name: msg
  id: parameter
  parameters:
    short_id: m
    type: str
    value: '"OpenWave pi/4-QPSK PHY test 123!"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Plots the diff_phasor_cc output - the recovered phase increments, immune to carrier phase offset. Four tight clusters at 45/135/225/315 degrees means the modem is decoding cleanly.
    gui_hint: 2,0,1,1
    size: '256'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Send
    type: string
    value: msg
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: qtgui_edit_box_msg_stats
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 3,0,1,1
    is_pair: 'False'
    label: Link Stats
    type: string
    value: '""'
  states: {}
- name: str_to_pdu_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Wraps an incoming string message (from a QT GUI Message Edit Box or the
      beacon strobe) into full OpenWave link-layer frame(s) - preamble, sync word,
      header (with real Payload Length, Sequence Number, and Flags fields), payload,
      and CRC32 - using the shared openwave_link module so TX and RX can't drift out
      of sync on the framing format. Ready for PDU to Tagged Stream.

      Messages longer than openwave_link.MAX_PAYLOAD_LEN are automatically split
      into multiple fragment frames (openwave_link.build_fragmented_frames) - each
      fragment is published as a separate PDU/burst, transparently to whoever
      called handle_msg. Sequence Number increments once per fragment (not once per
      logical message): a fragmented message consumes several consecutive seq
      numbers, one per fragment, since that's how RX's FragmentReassembler
      correlates them (see openwave_link.py's module docstring for the protocol-
      design gap this works around - there's no dedicated fragment-index field).

      ack_requested sets the Flags byte's ACK Requested bit and engages
      openwave_link.RetryManager, but ONLY for messages that fit in a single frame.
      RetryManager tracks one pending frame at a time, so partially tracking just a
      fragmented message's last fragment wouldn't actually guarantee the whole
      message arrived - fragmented sends are deliberately not ACK/retry-tracked in
      this phase, regardless of ack_requested.

      If 'tick' (wired to a periodic message strobe in the .grc) fires and the
      pending (unfragmented) frame has timed out, it's retransmitted, up to
      ack_max_retries times before giving up (published on 'delivery_failed'). The
      'ack_received' input is fed a real loop in this flowgraph specifically:
      stream_display_sink_0's ack_needed -> ack_responder_0 -> back through this
      same TX chain -> the channel -> stream_display_sink_0 again -> ack_received.
      tx_pluto.grc's copy of this block has no such loop (its RX counterpart,
      rx_rtlsdr.grc, has no transmit capability at all, so a real over-the-air ACK
      can never come back there) - only this simulated flowgraph can close the loop.
      """
      from gnuradio import gr
      import pmt
      import sys, os
      if os.getcwd() not in sys.path:
          sys.path.insert(0, os.getcwd())
      import openwave_link as link


      class blk(gr.basic_block):
          """String to OpenWave Frame PDU"""

          def __init__(self, lead_pad=24, end_pad=24, ack_requested=False,
                       ack_max_retries=3, ack_timeout_s=2.0):
              gr.basic_block.__init__(self, name='String to OpenWave Frame PDU', in_sig=[], out_sig=[])
              self.lead_pad = lead_pad
              self.end_pad = end_pad
              self.ack_requested = ack_requested
              self.flags = link.FLAG_ACK_REQUESTED if ack_requested else 0
              self.seq = 0
              self.retry_mgr = link.RetryManager(max_retries=ack_max_retries, timeout_s=ack_timeout_s)
              self._pending_payload = None
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_in(pmt.intern('ack_received'))
              self.message_port_register_in(pmt.intern('tick'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.message_port_register_out(pmt.intern('delivery_failed'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)
              self.set_msg_handler(pmt.intern('ack_received'), self.handle_ack_received)
              self.set_msg_handler(pmt.intern('tick'), self.handle_tick)

          def _publish_frame(self, frame):
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(frame), list(frame)))
              self.message_port_pub(pmt.intern('pdus'), pdu)

          def _send_single_frame(self, payload, seq):
              """Used only for retransmitting an already-unfragmented pending frame -
              fragmented messages are never retry-tracked, see class docstring."""
              frame = link.build_frame(payload, lead_pad=self.lead_pad, end_pad=self.end_pad,
                                        seq=seq, flags=self.flags)
              self._publish_frame(frame)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              text = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(msg)
              payload = text.encode('utf-8')

              frames, next_seq = link.build_fragmented_frames(
                  payload, seq_start=self.seq, flags=self.flags,
                  lead_pad=self.lead_pad, end_pad=self.end_pad,
              )
              fragmented = len(frames) > 1
              first_seq = self.seq
              self.seq = next_seq

              for frame in frames:
                  self._publish_frame(frame)

              if self.ack_requested and not fragmented:
                  self._pending_payload = payload
                  self.retry_mgr.note_sent(first_seq)

          def handle_ack_received(self, msg):
              acked_seq = pmt.to_long(msg)
              self.retry_mgr.note_ack(acked_seq)

          def handle_tick(self, msg):
              status = self.retry_mgr.poll()
              if status == 'retry':
                  seq = self.retry_mgr.pending_seq
                  self._send_single_frame(self._pending_payload, seq)
                  self.retry_mgr.note_sent(seq)
              elif status == 'give_up':
                  self.message_port_pub(pmt.intern('delivery_failed'), pmt.from_long(self.seq))
                  self._pending_payload = None
    ack_requested: 'True'
    end_pad: '24'
    lead_pad: '24'
    ack_max_retries: '3'
    ack_timeout_s: '2.0'
  states: {}
- name: stream_display_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Uses the 'sync' tag from the access-code correlator to know exactly where the
      header starts, then uses openwave_link.FrameParser to collect exactly
      Header+Payload+CRC32 bytes (per the header's real Payload Length field) and
      verify the CRC before publishing. No zero-run-terminator guessing - the header
      tells us exactly how many bytes to expect, and the CRC tells us whether we got
      them right.

      Tracks Sequence Number (gap/duplicate detection) and parses Flags from each
      CRC-verified frame - never from a CRC-failed one, since a corrupted header can
      still unpack without a struct error while holding garbage values. Counts and
      the last frame's seq/flags are published on the 'stats' port.

      Distinguishes three kinds of CRC-verified frame:
        - ACK frames (openwave_link.is_ack): publish the acknowledged seq on
          'ack_received' instead of trying to decode the (empty) payload as text.
          Deliberately excluded from the Data-frame seq/dup/lost tracker below - an
          ACK frame's Sequence Number mirrors the frame it's acknowledging (see
          openwave_link.build_ack_frame), not an independent counter of its own, so
          running it through that tracker would misreport every successful ACK as a
          duplicate of the original data frame.
        - Fragmented Data frames: fed through openwave_link.FragmentReassembler;
          'msg' is only published once the full run completes, transparently to
          whoever's listening on 'msg' (a reassembled message looks identical to a
          single-frame one).
        - Plain Data frames: decoded and published on 'msg' directly, as before.
      A Data frame (fragmented or not) with the ack_requested flag publishes its
      seq on 'ack_needed'.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys, os
      if os.getcwd() not in sys.path:
          sys.path.insert(0, os.getcwd())
      import openwave_link as link


      class blk(gr.sync_block):
          """Sync-word-aligned, header-framed bit stream to message"""

          def __init__(self, tagname='sync'):
              gr.sync_block.__init__(self, name='Framed Stream to Message', in_sig=[np.uint8], out_sig=[])
              self.tagname = tagname
              self.parser = link.FrameParser()
              self.reassembler = link.FragmentReassembler()
              self.armed = False
              self.bitpos = 0
              self.curbyte = 0
              self.counts = {'ok': 0, 'crc_fail': 0, 'bad_length': 0, 'dup': 0, 'lost': 0,
                              'acks_rx': 0, 'frag_aborted': 0, 'frag_overflow': 0}
              self.last_seq = None
              self.last_flags = 0
              self.message_port_register_out(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('stats'))
              self.message_port_register_out(pmt.intern('ack_needed'))
              self.message_port_register_out(pmt.intern('ack_received'))

          def _publish_stats(self):
              c = self.counts
              seq_str = str(self.last_seq) if self.last_seq is not None else '-'
              text = (f"OK:{c['ok']}  CRC fail:{c['crc_fail']}  Bad length:{c['bad_length']}  "
                      f"Dup:{c['dup']}  Lost:{c['lost']}  ACKs rx:{c['acks_rx']}  "
                      f"Frag abort:{c['frag_aborted']}  Frag overflow:{c['frag_overflow']}  |  "
                      f"Seq:{seq_str}  Flags:{link.format_flags(self.last_flags)}")
              self.message_port_pub(pmt.intern('stats'), pmt.string_to_symbol(text))

          def _update_seq(self, header):
              seq = header['seq']
              if self.last_seq is not None:
                  if seq == self.last_seq:
                      self.counts['dup'] += 1
                  else:
                      gap = (seq - self.last_seq - 1) % link.SEQ_MODULUS
                      # Bound the gap we'll believe as real loss vs. e.g. TX having
                      # restarted (seq reset to 0) - avoids one bogus huge count.
                      if 0 < gap < 1000:
                          self.counts['lost'] += gap
              self.last_seq = seq
              self.last_flags = header['flags']

          def _publish_text_and_maybe_ack(self, header, payload_bytes):
              self.counts['ok'] += 1
              text = payload_bytes.decode('utf-8', errors='replace')
              if text:
                  self.message_port_pub(pmt.intern('msg'), pmt.string_to_symbol(text))
              if link.needs_ack(header):
                  self.message_port_pub(pmt.intern('ack_needed'), pmt.from_long(header['seq']))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern(self.tagname))
              tag_offsets = {t.offset - self.nitems_read(0) for t in tags}

              for i, bit in enumerate(in0):
                  if i in tag_offsets:
                      self.parser.reset()
                      self.armed = True
                      self.bitpos = 0
                      self.curbyte = 0

                  if not self.armed:
                      continue

                  self.curbyte = (self.curbyte << 1) | int(bit)
                  self.bitpos += 1
                  if self.bitpos == 8:
                      status, payload = self.parser.feed(self.curbyte)
                      self.bitpos = 0
                      self.curbyte = 0
                      if status == 'ok':
                          header = self.parser.last_header

                          if link.is_ack(header):
                              self.counts['acks_rx'] += 1
                              self.message_port_pub(pmt.intern('ack_received'), pmt.from_long(header['seq']))
                          else:
                              self._update_seq(header)
                              if link.parse_flags(header['flags'])['fragmented']:
                                  frag_status, reassembled = self.reassembler.feed(header, payload)
                                  self.counts['frag_aborted'] = self.reassembler.abort_count
                                  self.counts['frag_overflow'] = self.reassembler.overflow_count
                                  if frag_status == 'complete':
                                      self._publish_text_and_maybe_ack(header, reassembled)
                              else:
                                  self._publish_text_and_maybe_ack(header, payload)

                          self._publish_stats()
                          self.armed = False
                      elif status in ('crc_fail', 'bad_length'):
                          self.counts[status] += 1
                          self._publish_stats()
                          self.armed = False

              return len(in0)
    tagname: '''sync'''
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: symbol rate in baud - one of the OpenWave modes 600/1200/2400/4800/9600
    short_id: r
    type: intx
    value: '9600'
  states: {}
- name: blocks_message_strobe_ack_tick
  id: blocks_message_strobe
  parameters:
    comment: Drives str_to_pdu_0's ACK-retry timeout polling - unrelated to (and much faster than) any beacon strobe in this flowgraph.
    msg: pmt.PMT_T
    period: '500'
  states: {}
- name: ack_responder_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Turns a needed-ACK notification (a Sequence Number, from
      stream_display_sink_0's 'ack_needed' port) into an actual ACK frame PDU,
      ready for PDU to Tagged Stream - the piece that was previously missing: RX
      could recognize that a received frame wanted acknowledging, but nothing
      built and transmitted the response.

      Deliberately simple, with no retry/reliability logic of its own - an ACK
      frame that itself gets lost just means the original sender's RetryManager
      will retry the original message and (if this response path is reachable
      again) get acknowledged on a later attempt.
      """
      from gnuradio import gr
      import pmt
      import sys, os
      if os.getcwd() not in sys.path:
          sys.path.insert(0, os.getcwd())
      import openwave_link as link


      class blk(gr.basic_block):
          """Ack Needed to ACK Frame PDU"""

          def __init__(self, lead_pad=24, end_pad=24):
              gr.basic_block.__init__(self, name='Ack Responder', in_sig=[], out_sig=[])
              self.lead_pad = lead_pad
              self.end_pad = end_pad
              self.message_port_register_in(pmt.intern('ack_needed'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('ack_needed'), self.handle_ack_needed)

          def handle_ack_needed(self, msg):
              acked_seq = pmt.to_long(msg)
              frame = link.build_ack_frame(acked_seq, lead_pad=self.lead_pad, end_pad=self.end_pad)
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(frame), list(frame)))
              self.message_port_pub(pmt.intern('pdus'), pdu)
    end_pad: '24'
    lead_pad: '24'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', stream_display_sink_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [qtgui_edit_box_msg_0, msg, str_to_pdu_0, msg]
- [str_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [stream_display_sink_0, msg, qtgui_edit_box_msg_1, val]
- [stream_display_sink_0, stats, qtgui_edit_box_msg_stats, val]
- [blocks_message_strobe_ack_tick, strobe, str_to_pdu_0, tick]
- [stream_display_sink_0, ack_needed, ack_responder_0, ack_needed]
- [ack_responder_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [stream_display_sink_0, ack_received, str_to_pdu_0, ack_received]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
